Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 6f0c0774-1e3b-4f87-87ee-fd168959264b, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: H1BL-01.ifc
Time: 2025-10-19T12:42:54+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: H1BL-01_R23:H1BL-01_R23, H1BL-01_R23:H1BL-01_R23:12768
In: Livello 1
Type - Material: Metal, wood, <Unnamed>
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: H1BL-01_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; altezza lama (cm): 83; altezza tot (cm): 83; applicazione: n.a.; ASI: 0,7; CAD layer: n.a.; certificato art 14 comma 22: TOCUSTOMIZE; certificato CE: TOCUSTOMIZE; certificato di corretta posa: TOCUSTOMIZE; classe: H1; classe intrusione del veicolo: VI7; classe larghezza di lavoro: W5; cordolo: n.a.; Costo: 218; deflessione dinamica (m): 1,4; Descrizione: (colore); documentazione integrativa (url): TOCUSTOMIZE; DOP: TOCUSTOMIZE; DSM: RiderPro-MRS-03; EPD: sì; GWP totale cradle to gate: 12,25 kgCO2eq/m; infissione (m): 1; interasse (m): 3; intrusione del veicolo (m): 2,5; larghezza di lavoro (m): 1,6; larghezza max (cm): 36; lavorazione aggiuntiva: TOCUSTOMIZE; Legno CAM Strade: CoC PEFC; livello di severità: A; lunghezza minima (m): 81; manuale di installazione: TOCUSTOMIZE; materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: H1BL-01; N° certificato CE: CPR/0491/3152; Nome del tipo: H1BL-01_R23; norma di riferimento: EN 1317-2 e EN1317-5; prezzo di capitolato: 218; prodotto: Barriera di sicurezza stradale; Produttore: Margaritelli Road Safety; progressiva finale: TOCUSTOMIZE; progressiva iniziale: TOCUSTOMIZE; resoconti di prova: TOCUSTOMIZE; supporto: rilevato; testata su arginello: no; tipologia: H1 Bordo Laterale; unità di misura: m; URL: https://margaritelli-rs.com/it/products/h1bl-01/; url (certificati CE, DOP, manuali, schede tecniche, schemi): https://margaritelli-rs.com/it/products/h1bl-01/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: H1BL-01_R23
Pset_RailingCommon - Reference: H1BL-01_R23; IsExternal: no
Altro - Bordo_Dx: yes; Bordo_SX: yes; Famiglia: H1BL-01_R23; Famiglia e tipo: H1BL-01_R23: H1BL-01_R23; ID tipo: 12752; No Of Railings: 2; Tipo: H1BL-01_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 14.5586 m2; Volume: 0.417561 m3
